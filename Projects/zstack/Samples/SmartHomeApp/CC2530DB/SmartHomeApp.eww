<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SmartHomeApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SmartHomeApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SmartHomeApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SmartHomeApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SmartHomeApp</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>SmartHomeApp</project>
        <configuration>CoordinatorEB-Pro</configuration>
      </member>
      <member>
        <project>SmartHomeApp</project>
        <configuration>RouterEB-Pro</configuration>
      </member>
      <member>
        <project>SmartHomeApp</project>
        <configuration>EndDeviceEB-Pro</configuration>
      </member>
      <member>
        <project>SmartHomeApp</project>
        <configuration>DemoEB-Pro</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


